# Keil uVision project STM32F746G_DISCO.uvprojx, settings and files
target STM32F746G_DISCO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF)                      CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F746G_DISCO +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_BPP=16
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../Drivers/Components/ft5336;../Drivers/BSP;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../touchgfx/App;../touchgfx/target;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/gui/include
  asm include: ..\Core\Inc;../Drivers/BSP
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: STM32F746G_DISCO.sct
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: command_RX.c Flash.c LM35_Temperature_Measurement.c ProcessData.c Alarm.c PowerManagement.c main.c gpio.c freertos.c adc.c crc.c dma.c dma2d.c fmc.c i2c.c ltdc.c quadspi.c spi.c tim.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c bootloader_entry.c
    ../Core/Inc/: bootloader_entry.h
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Drivers/Components
    ../Drivers/Components/ft5336/: ft5336.c
  group Drivers/BSP
    ../Drivers/BSP/: stm32746g_discovery_qspi.c
  group gui
    ../touchgfx/gui/src/containers/: clockanddatesetting.cpp digital_clock.cpp message_box.cpp numupdown.cpp ready.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/main_screen_screen/: main_screenpresenter.cpp main_screenview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/spalsh_screen_screen/: spalsh_screenpresenter.cpp spalsh_screenview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_tccm_____ttf_18_4bpp_0.cpp font_tccm_____ttf_18_4bpp_4.cpp font_tccm_____ttf_20_4bpp_0.cpp font_tccm_____ttf_20_4bpp_4.cpp font_tccm_____ttf_25_4bpp_0.cpp font_tccm_____ttf_25_4bpp_4.cpp font_tccm_____ttf_30_4bpp_0.cpp font_tccm_____ttf_30_4bpp_4.cpp font_tccm_____ttf_40_4bpp_0.cpp font_tccm_____ttf_40_4bpp_4.cpp font_tccm_____ttf_80_4bpp_0.cpp font_tccm_____ttf_80_4bpp_4.cpp fontcache.cpp generatedfont.cpp kerning_tccm_____ttf_18_4bpp.cpp kerning_tccm_____ttf_20_4bpp.cpp kerning_tccm_____ttf_25_4bpp.cpp kerning_tccm_____ttf_30_4bpp.cpp kerning_tccm_____ttf_40_4bpp.cpp kerning_tccm_____ttf_80_4bpp.cpp table_tccm_____ttf_18_4bpp.cpp table_tccm_____ttf_20_4bpp.cpp table_tccm_____ttf_25_4bpp.cpp table_tccm_____ttf_30_4bpp.cpp table_tccm_____ttf_40_4bpp.cpp table_tccm_____ttf_80_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_bat_symb_charging.cpp image_battery_symbol.cpp image_battery_symbol_stroked.cpp image_button_filled.cpp image_button_filled_small.cpp image_button_hollow.cpp image_button_hollow_gray.cpp image_clock_transparent.cpp image_clocksetting_background.cpp image_fw412_splashscreenlogo.cpp image_message_box_background.cpp image_scroll_back.cpp image_scroll_back_test.cpp image_title.cpp image_usb_symbol.cpp
    ../touchgfx/generated/gui_generated/src/containers/: clockanddatesettingbase.cpp digital_clockbase.cpp message_boxbase.cpp numupdownbase.cpp readybase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/main_screen_screen/: main_screenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/spalsh_screen_screen/: spalsh_screenviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_nor.c stm32f7xx_hal_sram.c stm32f7xx_hal_nand.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_qspi.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
